RDEPENDS_${PN} .= "	\
	dosfstools	\
	e2fsprogs	\
	genext2fs	\
	mtd-utils	\
	"
