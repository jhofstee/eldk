RDEPENDS_${PN} += " \
        libqt-embeddeddeclarative4-dev \
        libqt-embeddedxmlpatterns4-dev \
        qt-mobility-embedded-dev \
	dosfstools		\
	e2fsprogs		\
	e2fsprogs-tune2fs	\
	e2fsprogs-mke2fs	\
	e2fsprogs-e2fsck	\
        genext2fs		\
        mtd-utils		\
        "
