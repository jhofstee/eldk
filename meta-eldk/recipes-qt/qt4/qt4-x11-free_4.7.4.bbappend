QT_CONFIG_FLAGS_append_generic-armv6 = " -no-neon "
