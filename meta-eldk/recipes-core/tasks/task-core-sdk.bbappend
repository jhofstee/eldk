RDEPENDS_task-core-sdk .= "\
	dosfstools	\
	e2fsprogs	\
	genext2fs	\
	mtd-utils	\
	u-boot-mkimage	\
	"
